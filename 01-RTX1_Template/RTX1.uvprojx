# Keil uVision project RTX1.uvprojx, settings and files
target Sim - RTX Time (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RTX1
  c flags: Optim=1 uC99=1
  c include: .\includes
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Mains
    ./: RTXmainTime.c RTXmainSemaphore.c RTXmainSignalsPoll.c RTXmainSignalsIRQ.c RTXmainMessageQueue.c RTXmainMailQueue.c RTXmainUserTim.c RTXmainUserTimSig.c
  group HW
    ./: myIRQHandlerSignals.c myIRQHandlerMessageQueue.c myIRQHandlerMailQueue.c
target Sim - Semaphore (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: RTX1
  c flags: Optim=1 uC99=1
  c include: .\includes
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Sim - Signals Poll Key (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: RTX1
  c flags: Optim=1 uC99=1
  c include: .\includes
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Sim - Signals IRQ Key (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: RTX1
  c flags: Optim=1 uC99=1
  c include: .\includes
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Sim - Message Queue (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: RTX1
  c flags: Optim=1 uC99=1
  c include: .\includes
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Sim - Mail Queue (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: RTX1
  c flags: Optim=1 uC99=1
  c include: .\includes
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Sim - User Timer (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: RTX1
  c flags: Optim=1 uC99=1
  c include: .\includes
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Sim - User Timer Signal (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: RTX1
  c flags: Optim=1 uC99=1
  c include: .\includes
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Debug RTX Time (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: RTX1
  c flags: Optim=1 uC99=1
  c include: .\includes
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Debug Semaphore (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: RTX1
  c flags: Optim=1 uC99=1
  c include: .\includes
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Debug Signals Poll Key (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: RTX1
  c flags: Optim=1 uC99=1
  c include: .\includes
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Debug Signals IRQ Key (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: RTX1
  c flags: Optim=1 uC99=1
  c include: .\includes
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Debug Message Queue (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: RTX1
  c flags: Optim=1 uC99=1
  c misc: --c99
  c include: .\includes
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Debug Mail Queue (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: RTX1
  c flags: Optim=1 uC99=1
  c include: .\includes
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Debug User Timer (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: RTX1
  c flags: Optim=1 uC99=1
  c include: .\includes
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Debug User Timer Signal (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: RTX1
  c flags: Optim=1 uC99=1
  c include: .\includes
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, ETTI4:Embedded laboratory:Configurator 1.4.0, ETTI4:Embedded laboratory:Displays 5.0.0, ETTI4:Embedded laboratory:RTX 4.1.0, Compiler:I/O:STDOUT 1.0.0, Device:Startup 1.0.0
