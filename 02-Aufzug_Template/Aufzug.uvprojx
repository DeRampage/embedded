# Keil uVision project Aufzug.uvprojx, settings and files
target Simulation (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Aufzug
  c flags: Optim=1 uC99=1
  c include: .\includes
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Main
    ./: Aufzugmain.c
  group TastenLeds
    ./Tastenleds/: tastenleds.c
  group Alarm
    ./Alarm/: alarm.c
  group PosSensor
    ./possensor/: possensor.c
  group Motor
    ./StepperMotor/: StepperMotor.c
target Debugger RAM (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: Aufzug
  c flags: Optim=1 uC99=1
  c include: .\includes
  memory RVCT4: ROM 0x10000000 size 0x5000
  memory RVCT9: RAM 0x10005000 size 0x3000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, ETTI4:Embedded laboratory:Configurator 1.4.0, ETTI4:Embedded laboratory:Displays 5.0.0, ETTI4:Embedded laboratory:Elevator 4.0.1, Compiler:I/O:STDOUT 1.0.0, Device:Startup 1.0.0
