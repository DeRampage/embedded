# Keil uVision project EA.uvprojx, settings and files
target Simulator EA1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: EA
  c flags: Optim=1 uC99=1
  c include: .\includes
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source
    ./: ea_test1.c ea_test2.c ea_test3.c ea_test4.c ea_test5.c ea_test6.c ea_test7.c
  group HW
    ./Tastenleds/: tastenleds.c
    ./Alarm/: alarm.c
    ./possensor/: possensor.c
    ./StepperMotor/: StepperMotor.c
target Simulator EA2 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: EA
  c flags: Optim=1 uC99=1
  c include: .\includes
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Simulator EA3 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: EA
  c flags: Optim=1 uC99=1
  c include: .\includes
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Simulator EA4 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: EA
  c flags: Optim=1 uC99=1
  c include: .\includes
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Simulator EA5 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: EA
  c flags: Optim=1 uC99=1
  c include: .\includes
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Simulator EA6 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: EA
  c flags: Optim=1 uC99=1
  c include: .\includes
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Simulator EA7 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: EA
  c flags: Optim=1 uC99=1
  c include: .\includes
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Debug RAM EA1 (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: EA
  c flags: Optim=1 uC99=1
  c include: .\includes
  memory RVCT4: ROM 0x10000000 size 0x5000
  memory RVCT9: RAM 0x10005000 size 0x3000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Debug RAM EA2 (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: EA
  c flags: Optim=1 uC99=1
  c include: .\includes
  memory RVCT4: ROM 0x10000000 size 0x5000
  memory RVCT9: RAM 0x10005000 size 0x3000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Debug RAM EA3 (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: EA
  c flags: Optim=1 uC99=1
  c include: .\includes
  memory RVCT4: ROM 0x10000000 size 0x5000
  memory RVCT9: RAM 0x10005000 size 0x3000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Debug RAM EA4 (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: EA
  c flags: Optim=1 uC99=1
  c include: .\includes
  memory RVCT4: ROM 0x10000000 size 0x5000
  memory RVCT9: RAM 0x10005000 size 0x3000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Debug RAM EA5 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: EA
  c flags: Optim=1
  c misc: --c99
  c include: .\includes
  memory RVCT4: ROM 0x10000000 size 0x5000
  memory RVCT9: RAM 0x10005000 size 0x3000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Debug RAM EA6 (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: EA
  c flags: Optim=1 uC99=1
  c include: .\includes
  memory RVCT4: ROM 0x10000000 size 0x5000
  memory RVCT9: RAM 0x10005000 size 0x3000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Debug RAM EA7 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: EA
  c flags: Optim=1 uC99=1
  c include: .\includes
  memory RVCT4: ROM 0x10000000 size 0x5000
  memory RVCT9: RAM 0x10005000 size 0x3000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, ETTI4:Embedded laboratory:Configurator 1.4.0, ETTI4:Embedded laboratory:GPIO-EA 4.5.0, Device:Startup 1.0.0
